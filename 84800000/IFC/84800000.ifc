Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2x3 Coordination View
File name: D:\Users\Jonas\Documents\Cadfocus\Ostnor\Projekt\20140428_CAD-objekt_Siljan-Fryken\Arbetsmapp\termostat\84800000\AutoCAD Architecture\84800000.ifc
Time: 2014-05-15T15:37:51
Author: - -
Organization: Ostnor AB
Written by: Eurostep IFC Toolbox - 1.0
Made in: AutoCAD Architecture 2009 Build 5.7.68.0

# IfcProject, 84800000
LongName: 84800000
PSET_ACA_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: 02 - Normal detaljering; ACA_DISPLAY_SET_ON_EXPORT: 3D Normal

# IfcBuilding, 84800000
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingElementProxy: 84800000, BUILDINGELEMENTPROXY(1)
In: 84800000
Description: FM Mattsson Fryken Safety Mixer f/Shower 160 c/c, outlet down, chr
